## package/helium-gateway-rs/Config.in
```kconfig
config BR2_PACKAGE_HELIUM_GATEWAY_RS
	bool "helium-gateway-rs"
	help
	  https://github.com/helium/gateway-rs
```
